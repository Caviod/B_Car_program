# IAR project fire_Kinetis.ewp, settings and files
configuration FX15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR; DEBUG; ARM_MATH_CM4; MK60F15
  ICCARM.CCIncludePath2: ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_Kinetis.hex
  ILINK.IlinkOutputFile: fire_Kinetis.out
  ILINK.IlinkIcfFile: config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FX15_Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; IAR; ARM_MATH_CM4; MK60F15
  ICCARM.CCOptLevel: 3
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.FPU2: 0
  ICCARM.CCDefines: IAR; DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCOptLevel: 2
configuration DZ10_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; IAR; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: CL_FUN.c Control.c DebugFunction.c Drive.c Encode.c Get_UART.c i2c.c main.c main.h MPU6050.c MPU6050Drive.c My_I2C.c pid.c PIT.c PIT.h Recognition.c
    ../../App/Inc/: CL_FUN.h Control.h DebugFunction.h Drive.h Encode.h Get_UART.h i2c.h MPU6050.h MPU6050Drive.h My_I2C.h pid.h Recognition.h
  group Board
    ../../Board/src/: FIRE_key.c FIRE_LED.C FIRE_MK60_conf.c FIRE_MMA7455.c FIRE_NRF24L0.c FIRE_SCCB.c lcd.c SYN6288.c UART.c
    ../../Board/inc/: FIRE_MK60_conf.h
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: IIC.c misc.c MK60_adc.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group LIB/CMSIS
    ../../Lib/CMSIS/: iar_cortexM4l_math.a
